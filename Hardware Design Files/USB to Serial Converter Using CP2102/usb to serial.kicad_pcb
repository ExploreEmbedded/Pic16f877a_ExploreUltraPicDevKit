# Repository ExploreEmbedded/Pic16f877a_ExploreUltraPicDevKit

## KiCad design Hardware Design Files/USB to Serial Converter Using CP2102/usb to serial.kicad_pcb

Board: 2 copper layers, 30.0 x 20.0 mm, 10 parts (0 on the bottom side), 11 nets.

Parts:
C2: 0.1uF; SM0603
C3: 1uF; SM0603
CON1: USB-MINI-B; USB_Micro-B
D1: LED; SM0603
LOGO: LOGO (2)
P1: CONN_7; SIL-7
P2, P3: CONN_1; 1pin
R1: 330r; SM0603
U1: CP2102; cp2102_xl2

Connections:
/CTS: P1.2, U1.23
/D+: CON1.3, U1.4
/D-: CON1.2, U1.5
/DTR: P1.7, U1.28
/RTS: P1.6, U1.24
/RX: P1.5, U1.25
/TX: P1.4, U1.26
/VCC: C3.1, CON1.1, P1.3, R1.1, U1.7, U1.8
GND: C2.2, C3.2, CON1.4, CON1.5, CON1.6, D1.2, P1.1, U1.3
unnamed: C2.1, U1.6
unnamed: D1.1, R1.2

## KiCad design Hardware Design Files/Hardware_40pin_PICMCU/40pin_PICMCU.kicad_pcb

Parts:
C1, C2: 22pF
C3, C4: 0.1uF
D1, D2, D3: LED
JP1: JUMPER
P1, P2, P3, P4: CONN_10
P5: CONN_7
P6: ICSP
R1: 10K
R2, R3: R
SW1: rst
U1: 16F877A
X1: 20Mhz

Connections:
/+5V: C3.2, C4.2, P3.1, P5.3, P6.2, R1.2, R2.1, U1.11 (VDD), U1.32 (VDD)
/D6/PGC: P3.4, P6.5, U1.39 (RB6/PGC)
/D7/PGD: P3.3, P6.4, U1.40 (RB7/PGD)
/INT: P3.10, P4.2, U1.33 (RB0/INT)
/MCLR: JP1.1, P2.9, P6.1, R1.1, SW1.1, U1.1 (-MCLR/VPP)
/PE2: P2.10, U1.10 (RE2/AN7/CS_)
/RX: D3.1 (A), P1.10, P2.1, P5.4, U1.26 (RC7/RX/DT)
/TX: D2.1 (A), P1.9, P2.2, P5.5, U1.25 (RC6/TX/CK)
GND: C1.1, C2.1, C3.1, C4.1, D1.2 (K), P3.2, P5.1, P6.3, R3.2, SW1.2, U1.12 (VSS), U1.31 (VSS)
unnamed: P4.5, U1.28 (RD5/PSP5)
unnamed: P4.4, U1.29 (RD6/SPP6)
unnamed: P4.3, U1.30 (RD7/SPP7)
unnamed: P4.6, U1.27 (RD4/PSP4)
unnamed: P2.3, U1.24 (RC5/SDO)
unnamed: P2.4, U1.23 (RC4/SDI/SDA)
unnamed: P4.10, U1.19 (RD0/PSP0_)
unnamed: P4.9, U1.20 (RD1/PSP1)
unnamed: P4.8, U1.21 (RD2/PSP2)
unnamed: P4.7, U1.22 (RD3/PSP3)
unnamed: P1.7, U1.3 (RA1/AN1)
unnamed: P1.6, U1.4 (RA2/AN2/Vref-/CVRef)
unnamed: P2.5, U1.18 (RC3/SCK/SCL)
unnamed: P2.6, U1.17 (RC2/CCP1_)
unnamed: P2.7, U1.16 (RC1/T1OSI/CCP2)
unnamed: P2.8, U1.15 (RC0/T10S0/T1CK1)
unnamed: D2.2 (K), D3.2 (K), R3.1
unnamed: JP1.2, P5.7
unnamed: P3.9, U1.34 (RB1)
unnamed: P3.5, U1.38 (RB5)
unnamed: P3.6, U1.37 (RB4)
unnamed: P3.7, U1.36 (RB3/PGM)
unnamed: P3.8, U1.35 (RB2)
unnamed: D1.1 (A), R2.2
unnamed: C1.2, U1.13 (OSC1/CLKI), X1.2
unnamed: C2.2, U1.14 (OSC2/CLKO), X1.1
unnamed: P1.1, U1.9 (RE1/AN6/WR)
unnamed: P1.2, U1.8 (RE0/AN5/RD)
unnamed: P1.4, U1.6 (RA4/TOCKI_/C1OUT)
unnamed: P1.5, U1.5 (RA3/AN3/Vref+)
unnamed: P1.8, U1.2 (RA0/AN0)
unnamed: P1.3, U1.7 (RA5/AN4/SS/C2OUT)

Board: 2 copper layers, 40.0 x 75.0 mm, 21 parts (1 on the bottom side), 41 nets.

Other parts of the board:
EE_LOGO: EE_LOGO(2)

File Hardware Design Files/Hardware_40pin_PICMCU/BOM.xlsx:

Id | Designator | Package | Quantity | Designation | Supplier and ref
1 | R1 | SM1206 | 1 | 10K
2 | C1,C2 | SM1206 | 2 | 22pF
3 | C3,C4 | SM1206 | 2 | 0.1uF
4 | P6 | SIL-6 | 1 | ICSP
5 | P1,P2,P4,P3 | SIL-10 | 4 | CONN_10
6 | X1 | HC-49V | 1 | 20Mhz
7 | U1 | DIP-40__600_ELL | 1 | 16F877A
8 | R2,R3 | SM1206 | 2 | R
9 | D1,D2,D3 | SM1206 | 3 | LED
10 | P5 | SIL-7 | 1 | CONN_7
11 | JP1 | SIL-2 | 1 | JUMPER
12 | SW1 | SW_PUSH_SMALL_2pin_xl | 1 | rst

## Commit log

2016-05-03 Added Sample Codes
    Added Sample Codes for Pic16f877a.
    IDE: MPLABx
    compiler: x8 compiler
2016-05-07 Tutorial code updated
2016-05-18 Tutorial Examples added
2016-05-19 Added the PWM example
    Added the PWM example
2016-06-30 Code library updated
2016-08-18 Added Bootloader and Sample Code
    Added Bootloader and Sample Code
2017-09-23 Added GLcd example with libraries
